# Keil uVision project ble_simple_peripheral.uvproj, settings and files
target ble_simple_peripheral (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ble_simple_peripheral
  AfterMake: fromelf.exe  --text  -c -o Output/ble_simple_peripheral.txt  Objects/ble_simple_peripheral.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_simple_profile;..\code;..\..\..\..\components\modules\peripherals\capb18_air_pressure;..\..\..\..\components\modules\peripherals\oled;..\..\..\..\components\modules\peripherals\sht3x_temp_humi;..\..\..\..\components\ble\profiles\ble_audio_profile;..\..\..\..\components\modules\peripherals\audio;..\..\..\..\components\modules\decoder;..\..\..\..\components\modules\adpcm_ms;..\..\..\..\components\modules\peripherals\gyro;..\..\..\..\components\modules\ringbuffer;..\..\..\..\components\modules\adpcm_ima;..\cjson;..\bluetooth_cjson;..\code
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x40000000 size 0x4000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ble_simple_peripheral.c ble_simple_peripheral.h user_task.c time_rtc.c
    ../../../../components/modules/button/: button.c
  group profiles
    ../../../../components/ble/profiles/ble_audio_profile/: speaker_service.c speaker_service.h
    ../../../../components/ble/profiles/ble_simple_profile/: simple_gatt_service.c simple_gatt_service.h
  group display
    ../../../../components/modules/peripherals/oled/: lcd.c
  group audio
    ../../../../components/modules/peripherals/audio/: speaker.c
    ../../../../components/modules/adpcm_ms/: adpcm_ms.c
    ../../../../components/modules/decoder/: decoder.c
    ../../../../components/modules/RingBuffer/: ringbuffer.c
    ../../../../components/modules/adpcm_ima/: adpcm_ima.c
  group sensor
    ../../../../components/modules/peripherals/sht3x_temp_humi/: sht3x.c sht3x_sw_i2c.c sht3x_common.c sht3x_sw_i2c_implementation.c
    ../../../../components/modules/peripherals/capb18_air_pressure/: capb18-001.c
    ../../../../components/modules/peripherals/gyro/: gyro_driver.c gyro_alg.lib
  group driver
    ../../../../components/driver/: driver_iic.c driver_pmu.c driver_keyscan.c driver_pmu_qdec.c driver_rtc.c driver_uart.c driver_wdt.c driver_i2s.c driver_ssp.c driver_codec.c driver_exti.c driver_timer.c driver_efuse.c driver_pwm.c driver_pmu_pwm.c driver_adc.c
  group platform
    ../../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../../components/modules/patch/: patch.c
  group lib
    ../../../../components/ble/library/: fr8010h_stack.lib
  group cjson
    ../cjson/: cJSON.c test.c
  group bluetooth_process
    ../bluetooth_cjson/: cjson_process.c
