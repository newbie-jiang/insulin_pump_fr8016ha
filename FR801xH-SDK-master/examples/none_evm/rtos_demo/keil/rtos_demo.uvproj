# Keil uVision project rtos_demo.uvproj, settings and files
target rtos_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: ble_5_app
  AfterMake: fromelf.exe  --text  -c -o ble_5_app.txt  Objects/ble_5_app.axf
  AfterMake: fromelf.exe  --bin -o ble_5_app.bin  Objects/ble_5_app.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_ADV_MEM_ALLOOC_NEW,CFG_SIMPLE_PRINTF
  c include: ..\..\..\..\components\ble\include;..\..\..\..\components\driver\include;..\..\..\..\components\modules\os\include;..\..\..\..\components\modules\sys\include;..\..\..\..\components\modules\platform\include;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\lowpow\include;..\..\..\..\components\modules\button;..\..\..\..\components\modules\FreeRTOS\include;..\..\..\..\components\modules\FreeRTOS\portable\keil;..\..\..\..\components\ble\include\gap;..\..\..\..\components\ble\include\gatt;..\..\..\..\components\ble\profiles\ble_ota;..\code
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x40000000 size 0x4000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: .\ble_5_0.sct
  link misc: --feedback=feedback.txt ../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c prf_client.c prf_server.c user_task.c app_at.c rtos_entry.c
    ../../../../components/modules/button/: button.c
  group driver
    ../../../../components/driver/: driver_iic.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_timer.c driver_ssp.c driver_keyscan.c driver_wdt.c driver_i2s.c driver_codec.c driver_efuse.c driver_rtc.c driver_pwm.c driver_uart.c driver_exti.c driver_adc.c
  group platform
    ../../../../components/modules/platform/source/: core_cm3_isr.c app_boot_vectors.s
  group patch
    ../../../../components/modules/patch/: patch.c
  group lib
    ../../../../components/ble/library/: fr8010h_stack.lib
